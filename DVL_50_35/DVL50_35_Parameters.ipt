# Autodesk Inventor part: DVL50_35_Parameters
## iProperties
Created: 2009-07
Part Number: DVL50_35_Parameters
Document SubType Name: Modeling
Designer: TB
Density: 1 g/cm^3
Slaglengde: 100.000 mm
Vinkel_Plussport: 0.00 deg
Vinkel_Minusport: 0.00 deg
Forlengelse_rør: 0.000 mm
Author: TB
